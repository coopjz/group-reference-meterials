# Keil uVision project Nobody.uvprojx, settings and files
target NOBODY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nobody_creat +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CORE;.\FWLIB\inc;.\HardWare\IIC;.\HardWare\Moter;.\HardWare\OLED;.\HardWare\PWM;.\HardWare\TIME;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\HardWare\PSgame_hander;.\HardWare\Step;.\HardWare\Encoder;.\HardWare\LED;.\HardWare\DataScope_DP;.\HardWare\pneumatic;.\HardWare\ADC;.\HardWare\DMA;.\HardWare\Ray_dis
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
    ./USER/: stm32f4xx_it.c system_stm32f4xx.c Init.c Control.c
  group HardWare
    ./HardWare/Moter/: Moter.c
    ./HardWare/PWM/: pwm.c
    ./HardWare/TIME/: time.c
    ./HardWare/Encoder/: Encoder.c
    ./HardWare/LED/: LED.c
  group SYSTERM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group README
    ./: readme.txt
